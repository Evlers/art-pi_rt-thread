# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, STM32H750xx, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, USE_HAL_DRIVER
  c include: ..\rt-thread\components\dfs\dfs_v1\include;..\rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\libraries\wifi-host-driver\wifi-host-driver;..\rt-thread\components\dfs\dfs_v1\filesystems\elmfat;..\offline-packages\iot\webclient\inc;..\rt-thread\libcpu\arm\cortex-m7;..\rt-thread\components\net\lwip-dhcpd;..\rt-thread\components\net\sal\include;..\rt-thread\components\libc\posix\ipc;..\board;..\rt-thread\components\net\netdev\include;..;..\rt-thread\components\utilities\resource;..\rt-thread\components\libc\compilers\common\extension;..\rt-thread\components\utilities\ymodem;..\offline-packages\tools\easyflash\inc;..\rt-thread\components\drivers\include;..\libraries\wifi-host-driver\wifi-host-driver\WiFi_Host_Driver\resources\nvram\COMPONENT_43438\COMPONENT_AW-CU427-P;..\rt-thread\components\drivers\include;..\offline-packages\iot\nopoll\nopoll;..\rt-thread\include;..\board\port;..\rt-thread\components\drivers\spi\sfud\inc;..\offline-packages\misc\optparse;..\rt-thread\components\dfs\dfs_v1\filesystems\devfs;..\offline-packages\iot\pahomqtt\MQTTClient-RT;..\rt-thread\components\net\sal\include\socket\sys_socket;..\offline-packages\iot\netutils\ntp;..\offline-packages\security\mbedtls\mbedtls\library;..\applications;..\libraries\wifi-host-driver\wifi-host-driver\WiFi_Host_Driver\src\include;..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\board\port\fal;..\rt-thread\components\drivers\include;..\rt-thread\components\net\sal\impl;..\rt-thread\components\fal\inc;..\libraries\wifi-host-driver\wifi-host-driver\WiFi_Host_Driver\src;..\rt-thread\components\net\sal\include\socket;..\offline-packages\iot\pahomqtt\MQTTPacket\src;..\libraries\wifi-host-driver\wifi-host-driver\WiFi_Host_Driver\resources\resource_imp;..\rt-thread\components\drivers\include;..\board\port\filesystem;..\libraries\HAL_Drivers;..\rt-thread\libcpu\arm\common;..\rt-thread\components\dfs\dfs_v1\filesystems\romfs;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\libraries\wifi-host-driver\porting\inc\bsp;..\libraries\HAL_Drivers\drivers;..\rt-thread\components\drivers\wlan;..\offline-packages\security\mbedtls\ports\inc;..\rt-thread\components\net\lwip\lwip-2.0.3\src\include;..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\rt-thread\components\drivers\spi;..\rt-thread\components\libc\posix\io\poll;..\libraries\wifi-host-driver\wifi-host-driver\WiFi_Host_Driver\src\bus_protocols;..\libraries\wifi-host-driver\wifi-host-driver\WiFi_Host_Driver\inc;..\rt-thread\components\drivers\include;..\offline-packages\security\tinycrypt\include;..\offline-packages\security\mbedtls\mbedtls\include;..\board\port\wifi;..\libraries\wifi-host-driver\porting\inc\hal;..\offline-packages\iot\nopoll\sha1;..\rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;..\rt-thread\components\finsh;..\rt-thread\components\drivers\include;..\board\CubeMX_Config\Core\Inc;..\libraries\wifi-host-driver\porting\inc\rtos;..\offline-packages\language\JSON\cjson;..\rt-thread\components\net\lwip\port;..\board\port\sfud;..\offline-packages\iot\netutils\tftp;..\rt-thread\components\net\sal\include\dfs_net;..\libraries\HAL_Drivers\drivers\config;..\libraries\HAL_Drivers\CMSIS\Include;..\rt-thread\components\libc\posix\io\eventfd;..\rt-thread\components\libc\compilers\common\include;..\rt-thread\components\libc\posix\io\epoll;..\board\port\easyflash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\board\linker_scripts\link.sct
  group Applications
    ../applications/: main.c
  group cjson
    ../offline-packages/language/JSON/cjson/: cJSON.c cJSON_Utils.c
  group Compiler
    ../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    ../rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../rt-thread/components/drivers/core/: device.c
    ../rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../rt-thread/components/drivers/misc/: pin.c
    ../rt-thread/components/drivers/mtd/: mtd_nor.c
    ../rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    ../rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    ../rt-thread/components/drivers/serial/: serial.c
    ../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    ../board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    ../board/: board.c drv_mpu.c
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_sdmmc.c drv_spi.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group easyflash
    ../offline-packages/tools/easyflash/src/: ef_utils.c ef_env.c easyflash.c ef_log.c ef_env_legacy.c ef_iap.c ef_env_legacy_wl.c ef_cmd.c
  group easyflash-port
    ../board/port/easyflash/: ef_fal_port.c
  group Fal
    ../rt-thread/components/fal/src/: fal_partition.c fal_rtt.c fal.c fal_flash.c
    ../rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group fal-port
    ../board/port/fal/: fal_port.c
  group Filesystem
    ../rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c romfs.c
    ../rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group filesystem-port
    ../board/port/filesystem/: filesystem.c
  group Finsh
    ../rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc.c stm32h7xx_hal_spi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_rtc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_usart.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_nor.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pwr_ex.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group lwIP
    ../rt-thread/components/net/lwip-dhcpd/: dhcp_server_raw.c
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group mbedtls
    ../offline-packages/security/mbedtls/mbedtls/library/: des.c pkcs5.c chacha20.c ccm.c x509write_csr.c cipher.c padlock.c sha256.c x509_crt.c chachapoly.c psa_its_file.c x509_create.c dhm.c pkparse.c hkdf.c x509_crl.c asn1write.c ecdh.c pk.c pkwrite.c psa_crypto_storage.c cmac.c asn1parse.c hmac_drbg.c mps_trace.c psa_crypto_client.c ssl_tls.c psa_crypto_mac.c ecjpake.c psa_crypto_driver_wrappers.c x509.c certs.c rsa.c ssl_msg.c ssl_cli.c pk_wrap.c psa_crypto_cipher.c x509_csr.c pem.c ssl_srv.c cipher_wrap.c ecp.c gcm.c memory_buffer_alloc.c rsa_internal.c ssl_ciphersuites.c aes.c platform.c havege.c psa_crypto.c sha512.c xtea.c ctr_drbg.c nist_kw.c entropy.c psa_crypto_ecp.c threading.c ripemd160.c aria.c md4.c poly1305.c aesni.c error.c ssl_ticket.c constant_time.c md.c ssl_tls13_keys.c base64.c md2.c entropy_poll.c platform_util.c ssl_cache.c x509write_crt.c arc4.c ecp_curves.c psa_crypto_hash.c timing.c blowfish.c debug.c md5.c pkcs11.c sha1.c bignum.c ecdsa.c ssl_cookie.c psa_crypto_aead.c camellia.c oid.c pkcs12.c psa_crypto_slot_management.c version_features.c mps_reader.c psa_crypto_se.c psa_crypto_rsa.c version.c
    ../offline-packages/security/mbedtls/ports/src/: sha256_alt.c arc4_alt.c sha512_alt.c tls_certificate.c tls_client.c tls_hardware.c md5_alt.c des_alt.c rsa_alt.c timing_alt.c tls_net.c sha1_alt.c aes_alt.c
  group NetUtils
    ../offline-packages/iot/netutils/iperf/: iperf.c
    ../offline-packages/iot/netutils/netio/: netio.c
    ../offline-packages/iot/netutils/ntp/: ntp.c
    ../offline-packages/iot/netutils/tcpdump/: tcpdump.c
    ../offline-packages/iot/netutils/telnet/: telnet.c
    ../offline-packages/iot/netutils/tftp/: tftp_client.c tftp_port.c tftp_server.c tftp_xfer.c
  group nopoll
    ../offline-packages/iot/nopoll/nopoll/: nopoll_loop.c nopoll.c nopoll_listener.c nopoll_msg.c nopoll_decl.c nopoll_rtthread.c nopoll_log.c nopoll_io.c nopoll_conn_opts.c nopoll_conn.c nopoll_ctx.c
  group nopoll-examples
    ../offline-packages/iot/nopoll/examples/: nopoll_server.c nopoll_client.c
  group optparse
    ../offline-packages/misc/optparse/: optparse.c
  group paho-mqtt
    ../offline-packages/iot/pahomqtt/MQTTPacket/src/: MQTTUnsubscribeClient.c MQTTConnectServer.c MQTTSerializePublish.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSubscribeServer.c MQTTConnectClient.c MQTTSubscribeClient.c MQTTUnsubscribeServer.c
    ../offline-packages/iot/pahomqtt/samples/: mqtt_sample.c
    ../offline-packages/iot/pahomqtt/MQTTClient-RT/: paho_mqtt_pipe.c
  group POSIX
    ../rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group SAL
    ../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../rt-thread/components/net/sal/dfs_net/: dfs_net.c
    ../rt-thread/components/net/sal/impl/: af_inet_lwip.c
    ../rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    ../rt-thread/components/net/sal/src/: sal_socket.c
  group sfud-port
    ../board/port/sfud/: sfud_port.c
  group tinycrypt
    ../offline-packages/security/tinycrypt/src/: tiny_md5.c tiny_base64.c tiny_aes.c tiny_sha1.c tiny_sha2.c
  group Utilities
    ../rt-thread/components/utilities/resource/: resource_id.c
    ../rt-thread/components/utilities/ymodem/: ymodem.c
  group webclient
    ../offline-packages/iot/webclient/src/: webclient.c webclient_file.c
  group whd
    ../libraries/wifi-host-driver/wifi-host-driver/WiFi_Host_Driver/src/: whd_ap.c whd_utils.c whd_wifi_p2p.c whd_logging.c whd_wifi_api.c whd_sdpcm.c whd_msgbuf_txrx.c whd_clm.c whd_flowring.c whd_chip_constants.c whd_network_if.c whd_chip.c whd_commonring.c whd_cdc_bdc.c whd_thread.c whd_resource_if.c whd_debug.c whd_proto.c whd_events.c whd_management.c whd_wifi.c whd_buffer_api.c whd_ring.c
    ../libraries/wifi-host-driver/porting/src/resources/: download.c resources.c
    ../libraries/wifi-host-driver/porting/src/rtos/: whd_rtos.c
    ../libraries/wifi-host-driver/porting/src/bsp/: cy_network_buffer.c cybsp.c
    ../libraries/wifi-host-driver/wifi-host-driver/WiFi_Host_Driver/src/bus_protocols/: whd_bus_common.c whd_bus_sdio_protocol.c whd_bus.c
    ../libraries/wifi-host-driver/porting/src/hal/: cyhal_sdio.c cyhal_gpio.c
    ../libraries/wifi-host-driver/porting/src/wlan/: whd_wlan.c
  group wifi-port
    ../board/port/wifi/: wifi_config.c
